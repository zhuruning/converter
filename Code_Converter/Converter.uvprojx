# Keil uVision project Converter.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F030C8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00002000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Converter +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F030
  c include: .\FWLIB\STM32F0xx_StdPeriph_Driver\inc;.\FWLIB\CMSIS\Include;.\FWLIB\CMSIS\Device\ST\STM32F0xx\Include;.\USER;.\STM32F0xx_StdPeriph_Lib_V1.5.0\Projects\STM32F0xx_StdPeriph_Examples\USART\USART_TwoBoards\DataExchangeInterrupt
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CODE
    ./FWLIB/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f030.s
  group FWLIB
    ./FWLIB/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group USER
    ./USER/: main.c stm32f0xx_it.c system_stm32f0xx.c
